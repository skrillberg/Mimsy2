# IAR project Mimsy2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Mimsy2.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../cc2538_foundation_firmware_1_0_1_0/bsp/srf06bb_cc2538/examples/leds/source/: leds_example.c
  group applications
    applications/: led_example.c
  group driverlib
    ../cc2538_foundation_firmware_1_0_1_0/driverlib/cc2538/source/: adc.c aes.c ccm.c cpu.c debug.c flash.c gpio.c gptimer.c i2c.c interrupt.c ioc.c pka.c sha256.c sleepmode.c ssi.c sys_ctrl.c systick.c uart.c udma.c watchdog.c
  group driverlib/headers
    ../cc2538_foundation_firmware_1_0_1_0/driverlib/cc2538/source/: adc.h aes.h bl_commands.h ccm.h cpu.h debug.h ecc_curveinfo.h flash.h gpio.h gptimer.h i2c.h interrupt.h ioc.h pka.h rom.h sha256.h sleepmode.h ssi.h sys_ctrl.h systick.h uart.h udma.h watchdog.h
  group inc
    ../cc2538_foundation_firmware_1_0_1_0/driverlib/cc2538/inc/: hw_aes.h hw_ana_regs.h hw_cctest.h hw_flash_ctrl.h hw_gpio.h hw_gptimer.h hw_i2cm.h hw_i2cs.h hw_ints.h hw_ioc.h hw_memmap.h hw_nvic.h hw_pka.h hw_rfcore_ffsm.h hw_rfcore_sfr.h hw_rfcore_xreg.h hw_smwdthrosc.h hw_soc_adc.h hw_ssi.h hw_sys_ctrl.h hw_types.h hw_uart.h hw_udma.h hw_udmachctl.h hw_usb.h
