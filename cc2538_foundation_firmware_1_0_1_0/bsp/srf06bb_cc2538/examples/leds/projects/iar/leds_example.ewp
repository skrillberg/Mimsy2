# IAR project leds_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; ENABLE_ASSERT; CC2538_USE_ALTERNATE_INTERRUPT_MAP
  ICCARM.CCIncludePath2: ..\..\..\..\drivers\source; ..\..\..\..\..\..\driverlib\cc2538\inc; ..\..\..\..\..\..\driverlib\cc2538\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: leds_example.bin
  ILINK.IlinkOutputFile: leds_example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    ../../source/: leds_example.c
    ../../../startup_files/: startup_iar.c
  group bsp
    ../../../../drivers/source/: bsp.c bsp.h bsp_led.c
  group driverlib
    ../../../../../../driverlib/cc2538/source/: adc.c cpu.c debug.c flash.c gpio.c gptimer.c i2c.c interrupt.c ioc.c sleepmode.c ssi.c sys_ctrl.c systick.c uart.c udma.c watchdog.c
  group driverlib/headers
    ../../../../../../driverlib/cc2538/source/: adc.h cpu.h debug.h flash.h gpio.h gptimer.h i2c.h interrupt.h ioc.h sleepmode.h ssi.h sys_ctrl.h systick.h uart.h udma.h watchdog.h
  group inc
    ../../../../../../driverlib/cc2538/inc/: hw_aes.h hw_ana_regs.h hw_flash_ctrl.h hw_gpio.h hw_gptimer.h hw_i2cm.h hw_i2cs.h hw_ints.h hw_ioc.h hw_memmap.h hw_nvic.h hw_pka.h hw_rfcore_ffsm.h hw_rfcore_sfr.h hw_rfcore_xreg.h hw_smwdthrosc.h hw_soc_adc.h hw_ssi.h hw_sys_ctrl.h hw_types.h hw_uart.h hw_udma.h hw_udmachctl.h hw_usb.h
  group mimsy
    ../../../../../../../Applications/Mimsy2_BSP_drivers/bsp/: led.c
