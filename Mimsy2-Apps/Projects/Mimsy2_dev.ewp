# IAR project Mimsy2_dev.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538NF53 TexasInstruments CC2538NF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\cc2538_foundation_firmware_1_0_1_0\driverlib\cc2538\inc; ..\..\cc2538_foundation_firmware_1_0_1_0\driverlib\cc2538\source; ..\..\Mimsy2-BSP-drivers\bsp; ..\..\Mimsy2-BSP-drivers\drivers; ..\..\Mimsy2-Apps
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Mimsy2_dev.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group applications
    ../applications/: leds_example.c leds_example.h
    Startup/: startup_iar.c
  group bsp_mimsy
    ../../Mimsy2-BSP-drivers/bsp/: inchworm.c inchworm.h led.c led.h
  group driverlib
    ../../cc2538_foundation_firmware_1_0_1_0/driverlib/cc2538/source/: adc.c aes.c ccm.c cpu.c debug.c flash.c gpio.c gptimer.c i2c.c interrupt.c ioc.c pka.c sha256.c sleepmode.c ssi.c sys_ctrl.c systick.c uart.c udma.c watchdog.c
  group driverlib/headers
    ../../cc2538_foundation_firmware_1_0_1_0/driverlib/cc2538/source/: adc.h aes.h bl_commands.h ccm.h cpu.h debug.h ecc_curveinfo.h flash.h gpio.h gptimer.h i2c.h interrupt.h ioc.h pka.h rom.h sha256.h sleepmode.h ssi.h sys_ctrl.h systick.h uart.h udma.h watchdog.h
  group inc
    ../../cc2538_foundation_firmware_1_0_1_0/driverlib/cc2538/inc/: hw_aes.h hw_ana_regs.h hw_cctest.h hw_flash_ctrl.h hw_gpio.h hw_gptimer.h hw_i2cm.h hw_i2cs.h hw_ints.h hw_ioc.h hw_memmap.h hw_nvic.h hw_pka.h hw_rfcore_ffsm.h hw_rfcore_sfr.h hw_rfcore_xreg.h hw_smwdthrosc.h hw_soc_adc.h hw_ssi.h hw_sys_ctrl.h hw_types.h hw_uart.h hw_udma.h hw_udmachctl.h hw_usb.h
